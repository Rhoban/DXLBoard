File: electronics/dxlboard.brd (EAGLE design)
At the start: 48.8 x 71 mm, 53 parts

Commit message: Updating FARNELL attributes & making BOM
Parts:
- R8: value (none) -> 10K
- R9: value (none) -> 1K
